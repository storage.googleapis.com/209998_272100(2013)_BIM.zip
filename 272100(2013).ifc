Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-19T17:15:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 19 17:15:28 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{011A0218-C3CB-4460-9AF6-CB1EFA25AEDE}\ifc * Database version: 5507 * Database creation date: Thu May 19 17:15:27 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 19 17:15:27 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 19 17:15:27 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 272100 Remote valve, 3 V, 272100(2013):272100 Remote valve, 3 V:427089
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 22.95 mm; NominalHeight: 51.9892 mm; NominalWidth: 51.9892 mm
Type - Electrical Engineering - Battery: AA 1.5 V Lithium x 2, CR 2450 3 V; Operating Voltage: 3 V; Protection Class: IP 54
Type - General - Author: BIMStone; BIMObjectName: 272100(2013); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/03/2022
Type - Green Building Properties - EAN Number: 6414150072475; EMC Directive: 2014/30/EU , 2011/65/EU; ETIM Class Number: EC010340 Electronic tap; LVI Number: 6219103; Noise Class: I (ISO 3822); NRF Number: 4203158; RSK Number: 8323002; Sales Package dimensions (LxWxH): 210 x 165 x 60; Sales Package gross weight: 0.52 kg; Sales Package package weight: 0.12531 kg; UNSPSC Class Number: 30181800 Faucet and shower heads, jets and parts and accessories; URL Declaration of Conformity: http://static.oras.com/DoC/272100; URL REACH: http://static.oras.com/doc/reach; URL UN38.3: http://static.oras.com/UN383/272100; URL WEEE: http://static.oras.com/WEEE/272100
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/272100; Catalog Drawing URL: http://static.oras.com/catdrw/272100; Dimension Drawing URL: http://static.oras.com/dimdrw/272100; FDV Document URL: http://www.oras.com/datasheet/272100/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/272100; Group: Washing machine valve; Installation and Maintenance Guide URL: http://static.oras.com/manual/272100; Interactive AR View URL: https://static.oras.com/AR/272100; Item Type: Sales item; Long Marketing: Oras remote valve for dishwasher or washing machine. The product consists of Smart Press Pad, control unit and electronic valve. Valve’s open duration is preset to 4h. Battery operated (3 V).; Manufacturer: Oras; Market: International;Estonia;Finland;Latvia;Lithuania;Norway;Poland;Russia;Sweden;Ukraine;Denmark; Mobile Product Information URL: http://mpi.oras.com/272100; Model: 272100 Remote valve, 3 V; Name_en: 272100 Remote valve, 3 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 272100; Product Family: Oras; Product Image URL: http://static.oras.com/image/272100; Product URL: http://static.oras.com/272100; Spare-Part Information URL: http://static.oras.com/sp/272100; Technical DataSheet URL: http://www.oras.com/datasheet/272100/en; Type Name: 272100 Remote valve, 3 V; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - ValveMainMaterial: Brass
Type - Mechanical - Dishwasher Valve Open Period: 4 h / 12 h; DN Size: 52 mm; Electronic Parts: Solenoid valve;External control unit;Low battery indicator; Flow Rate At 300kPa: 0.00953496 m3/s; Installation Type: Deck mounted; Max. Hot Water Supply: 70 kg/K/s3; Pressure Loss With Flow 02ls: 160000 Pa; Surface treatment: Chrome; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 272100(2013); Features: Battery-operated; Finish: Polished; Grade: n/a; Material: brassPlastic; ModelNumber: n/a; ModelReference: 272100; Name: 272100 Remote valve, 3 V; ReplacementCost: n/a; Shape: Sculptured; Size: 55x55x25 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 272100; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 272100 Remote valve, 3 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; TopMounting: yes
Dimensions - Angle: 45 deg; Area: 0.00508918 m2; Volume: 0.0000620309 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 272100(2013): 272100 Remote valve, 3 V; Family and Type: 272100(2013): 272100 Remote valve, 3 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 272100(2013): 272100 Remote valve, 3 V; Type Id: 272100(2013): 272100 Remote valve, 3 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
